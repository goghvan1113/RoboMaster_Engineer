# Keil uVision project RMChassisControl.uvprojx, settings and files
target RMChassisControl (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: gimbal +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\SYSTEM\DELAY;..\SYSTEM\SYS;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\portable;..\HARDWARE\ADRC_CONTROL;..\HARDWARE\BSP_INIT;..\HARDWARE\CAN;..\HARDWARE\PID_CONTROLLER_RAMP;..\HARDWARE\PID_CONTROLLER_RAMP\RAMP;..\HARDWARE\USART;..\HARDWARE\TIM;..\CONTROL\CHASISS_RUN;..\CONTROL\JUDGE_CONTROL;..\CONTROL\MODE_CHOOSE;..\CONTROL\MINE_CONTROL;..\CHASSIS_TASK\INIT_TASK;..\CHASSIS_TASK\TIM_TASK;..\JUDGE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/BSP_INIT/: bsp_init.c
    ../HARDWARE/USART/: usart.c data_fifo.c
    ../HARDWARE/PID_CONTROLLER_RAMP/: pid.c pid_controller.c
    ../HARDWARE/PID_CONTROLLER_RAMP/RAMP/: ramp.c
    ../HARDWARE/CAN/: can.c can_task.c
    ../HARDWARE/TIM/: tim.c
  group CONTROL
    ../CONTROL/CHASISS_RUN/: chassis_run.c
    ../CONTROL/MINE_CONTROL/: mine_control.c
    ../CONTROL/MODE_CHOOSE/: mode_choose.c
    ../CONTROL/JUDGE_CONTROL/: judge_control.c
  group CHASSIS_TASK
    ../CHASSIS_TASK/INIT_TASK/: init_task.c
    ../CHASSIS_TASK/TIM_TASK/: tim_task.c
  group JUDGE
    ../JUDGE/: CRCCheck.c judge_interact.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_tim.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
