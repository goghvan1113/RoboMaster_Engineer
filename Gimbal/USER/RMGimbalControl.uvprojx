# Keil uVision project RMGimbalControl.uvprojx, settings and files
target RMGimbalControl (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: gimbal +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\SYSTEM\DELAY;..\SYSTEM\SYS;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\portable;..\HARDWARE\BSP_INIT;..\HARDWARE\CAN;..\HARDWARE\TIM;..\HARDWARE\USART;..\HARDWARE\LED;..\HARDWARE\DBUS_REMOTE;..\GIMBAL_TASK\INIT_TASK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDAWARE
    ../HARDWARE/BSP_INIT/: bsp_init.c
    ../HARDWARE/CAN/: can.c can_task.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/USART/: usart.c data_fifo.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DBUS_REMOTE/: dbus_remote.c
  group GIMBAL_TASK
    ../GIMBAL_TASK/INIT_TASK/: init_task.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_tim.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
